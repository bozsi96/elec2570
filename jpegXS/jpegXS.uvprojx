# Keil uVision project jpegXS.uvprojx, settings and files
target jpegXS (6160000::V6.16::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: jpegXS
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe Objects\*.axf --vhx --32x1 --output ./output/code.hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: src/include/
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./src/: bitpacking.c budget.c dwt53.c gcli.c image_transforms.c lvls_map.c main.c packing.c precinct.c precinct_budget.c rate_control.c sb_weighting.c sig_mag.c tco_conf.c tco_enc.c xs_markers.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.2.2
